# Keil uVision project ADC.uvprojx, settings and files
target ADC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart4;..\USER;..\HARDWARE\LED;..\HARDWARE\ADC;..\HARDWARE\MQ2;..\HARDWARE\BATTERY;..\HARDWARE\LORA;..\HARDWARE\SPI;..\HARDWARE\GPS;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\HARDWARE\USART3;..\FWLIB\inc;..\HARDWARE\RTC;..\HARDWARE\MQTT4G;..\HARDWARE\BMP280;..\HARDWARE\I2C;..\HARDWARE\SHT2X;..\HARDWARE\TIMER2;..\HARDWARE\USART5;..\HARDWARE\USART6;..\HARDWARE\MQ7;..\SYSTEM\flash
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MQ2/: mq2.c
    ../HARDWARE/BATTERY/: battery.c
    ../HARDWARE/LORA/: lora.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MQTT4G/: mqtt4g.c usart1.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/BMP280/: bmp280.c
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/SHT2X/: SHT2X.c
    ../HARDWARE/TIMER2/: timer2.c
    ../HARDWARE/USART5/: usart5.c
    ../HARDWARE/USART6/: usart6.c
    ../HARDWARE/MQ7/: mq7.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart4/: usart4.c
    ../SYSTEM/flash/: flash.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_flash.c
  group README
    ../: readme.txt
